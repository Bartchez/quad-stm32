# Keil uVision project lab1.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab1 +hex
  c flags: Optim=1
  c include: ..\_Application;..\..\Libraries\CMSIS\Core\CM3;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ../_Application/: main.c stm32f10x_it.c LCD_4bit.c gps.c usart.c rfm12.c 18B20.c rfm12_controller.c i2c.c MPL115A2.c
  group Std Periph Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c
  group Startup
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
